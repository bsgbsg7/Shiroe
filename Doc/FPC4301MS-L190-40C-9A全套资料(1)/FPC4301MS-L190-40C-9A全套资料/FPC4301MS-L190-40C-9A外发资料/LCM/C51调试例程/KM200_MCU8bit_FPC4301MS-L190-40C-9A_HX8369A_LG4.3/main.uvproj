# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c POWER.C
    ./lcd/: lcd.c
